# Keil uVision project SmartSlot-Matrix.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartSlot-Matrix
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\User;.\System\delay;.\System\sys;.\System\timer;.\System\usart;.\Start;.\Library;.\Hardware;.\System\RTC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Libary
    ./Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md_vl.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group System
    ./System/delay/: delay.c
    ./System/RTC/: MyRTC.c
    ./System/sys/: sys.c
    ./System/timer/: timer1.c timer2.c timer3.c timer4.c
    ./System/usart/: usart1.c usart2.c usart3.c
  group Hardware
    ./Hardware/: 24c02.c 24c02.h Beep.c Beep.h iic.c iic.h Keys.c Keys.h OLED.c OLED.h OLED_Font.h ir_sensor.c ir_sensor.h RC522.c RC522.h ds1302.c ds1302.h Motor.c Motor.h
  group User
    ./User/: main.c main.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
